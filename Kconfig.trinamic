## Kconfig.trinamic
```kconfig
# Copyright (c) 2022, Stefano Cottafavi <stefano.cottafavi@gmail.com>
#
# SPDX-License-Identifier: Apache-2.0

config HAS_TMCLIB
	bool
```
